# Keil uVision project Lab1.uvproj, settings and files
target HelloWorld (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: .\CORE;.\FreeRTOS_CORE\include;.\FreeRTOS_PORTABLE;.\Hardware;.\SYSTEM\sys;.\SYSTEM\delay;.\STM32F4xx_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ./: startup_stm32f40_41xxx.s
    ./CORE/: stm32f4xx_it.c system_stm32f4xx.c
  group Main
    ./: main.c
  group STM32F4xx_Driver
    ./STM32F4xx_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c system.c
    ./SYSTEM/delay/: delay.c
  group HARDWARE
    ./Hardware/: led.c buz.c oled.c show.c
  group FREERTOS
    ./FreeRTOS_CORE/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS_PORTABLE/: heap_4.c port.c
